# Keil uVision project LVGL_F429_X-TRACK.uvprojx, settings and files
target LVGL_F429_X-TRACK (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LVGL_F429_X-TRACK
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F429_439xx,USE_STDPERIPH_DRIVER
  c misc: --gnu --diag_suppress=68 --diag_suppress=111 --diag_suppress=188
  c include: ..\board;..\board\fwlib\CMSIS\Device\ST\STM32F4xx\Include;..\board\fwlib\CMSIS\Include;..\board\fwlib\STM32F4xx_StdPeriph_Driver\inc;..\board\driver\include;..\func;..\func\FreeRTOS;..\func\FreeRTOS\FreeRTOS-Kernel\include;..\func\FreeRTOS\FreeRTOS-Kernel\portable\RVDS\ARM_CM4F;..\user\include;..\app;..\app\include;..\board\periph\led;..\board\periph\key;..\board\periph\lcd_led;..\board\periph\ft5206;..\func\lvgl_v8
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ../user/: main.cpp template.c
  group app
    ../app/: task_monitor.cpp task_key.cpp task_led.cpp task_gps.cpp task_lvgl.cpp app.cpp Version.h
  group Config
    ../app/Config/: Config.h
  group Common/DataPorc
    ../app/Common/DataProc/: DP_LIST.inc DataProc.cpp DataProc.h DataProc_Def.h DP_Clock.cpp DP_GPS.cpp DP_IMU.cpp DP_MAG.cpp DP_MusicPlayer.cpp DP_Power.cpp DP_Recorder.cpp DP_SportStatus.cpp DP_Storage.cpp DP_SysConfig.cpp DP_TrackFilter.cpp DP_TzConv.cpp
  group Pages
    ../app/Pages/: AppFactory.cpp AppFactory.h Page.h
  group Pages/StatusBar
    ../app/Pages/StatusBar/: StatusBar.cpp StatusBar.h
  group Pages/StartUp
    ../app/Pages/StartUp/: StartUp.cpp StartUp.h StartUpModel.cpp StartUpModel.h StartUpView.cpp StartUpView.h
  group Pages/Dialplate
    ../app/Pages/Dialplate/: Dialplate.cpp Dialplate.h DialplateModel.cpp DialplateModel.h DialplateView.cpp DialplateView.h
  group Pages/LiveMap
    ../app/Pages/LiveMap/: LiveMap.cpp LiveMap.h LiveMapModel.cpp LiveMapModel.h LiveMapView.cpp LiveMapView.h
  group Pages/SystemInfos
    ../app/Pages/SystemInfos/: SystemInfos.cpp SystemInfos.h SystemInfosModel.cpp SystemInfosModel.h SystemInfosView.cpp SystemInfosView.h
  group Resource
    ../app/Resource/: ResourcePool.cpp ResourcePool.h
  group Resource/Font
    ../app/Resource/Font/: font_agencyb_36.c font_bahnschrift_13.c font_bahnschrift_17.c font_bahnschrift_32.c font_bahnschrift_65.c font_bahnschrift_24.c font_bahnschrift_96.c
  group Resource/Image
    ../app/Resource/Image/: img_src_alarm.c img_src_battery.c img_src_battery_info.c img_src_bicycle.c img_src_compass.c img_src_gps_arrow.c img_src_gps_pin.c img_src_gyroscope.c img_src_locate.c img_src_map_location.c img_src_menu.c img_src_origin_point.c img_src_pause.c img_src_satellite.c img_src_sd_card.c img_src_start.c img_src_stop.c img_src_storage.c img_src_system_info.c img_src_time_info.c img_src_trip.c
  group Utils/lv_allocator
    ../app/Utils/lv_allocator/: lv_allocator.h
  group Utils/lv_ext
    ../app/Utils/lv_ext/: lv_label_anim_effect.cpp lv_obj_ext_func.cpp lv_anim_timeline.c
  group Utils/MapConv
    ../app/Utils/MapConv/: MapConv.cpp MapConv.h
  group Utils/PageManager
    ../app/Utils/PageManager/: PageBase.h PageFactory.h PageManager.h PM_Anim.cpp PM_Base.cpp PM_Drag.cpp PM_Router.cpp PM_State.cpp PM_Log.h ResourceManager.cpp ResourceManager.h
  group Utils/DataCenter
    ../app/Utils/DataCenter/: Account.cpp Account.h DataCenter.cpp DataCenter.h PingPongBuffer.c PingPongBuffer.h
  group Utils/Filters
    ../app/Utils/Filters/: FilterBase.h Filters.h HysteresisFilter.h LowpassFilter.h MedianFilter.h MedianQueueFilter.h SlidingFilter.h
  group Utils/TileSystem
    ../app/Utils/TileSystem/: TileSystem.cpp TileSystem.h
  group Utils/Time
    ../app/Utils/Time/: DateStrings.cpp Time.cpp Time.h TimeLib.h
  group Utils/TrackFilter
    ../app/Utils/TrackFilter/: TrackFilter.h TrackLineFilter.cpp TrackLineFilter.h TrackPointFilter.cpp TrackPointFilter.h
  group Utils/TileConv
    ../app/Utils/TileConv/: TileConv.cpp TileConv.h
  group freertos
    ../func/FreeRTOS/FreeRTOS-Kernel/: list.c queue.c tasks.c timers.c
    ../func/FreeRTOS/FreeRTOS-Kernel/portable/MemMang/: heap_4.c
    ../func/FreeRTOS/FreeRTOS-Kernel/portable/RVDS/ARM_CM4F/: port.c
    ../func/FreeRTOS/: FreeRTOSConfig.h
  group lvgl_core
    ../func/lvgl_v8/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group lvgl_draw
    ../func/lvgl_v8/lvgl/src/draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group lvgl_extra
    ../func/lvgl_v8/lvgl/src/extra/: lv_extra.c
    ../func/lvgl_v8/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../func/lvgl_v8/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../func/lvgl_v8/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../func/lvgl_v8/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../func/lvgl_v8/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../func/lvgl_v8/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../func/lvgl_v8/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../func/lvgl_v8/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../func/lvgl_v8/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../func/lvgl_v8/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../func/lvgl_v8/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../func/lvgl_v8/lvgl/src/extra/widgets/led/: lv_led.c
    ../func/lvgl_v8/lvgl/src/extra/widgets/list/: lv_list.c
    ../func/lvgl_v8/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../func/lvgl_v8/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../func/lvgl_v8/lvgl/src/extra/widgets/span/: lv_span.c
    ../func/lvgl_v8/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../func/lvgl_v8/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../func/lvgl_v8/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../func/lvgl_v8/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../func/lvgl_v8/lvgl/src/extra/widgets/win/: lv_win.c
  group lvgl_font
    ../func/lvgl_v8/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group lvgl_hal
    ../func/lvgl_v8/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lvgl_misc
    ../func/lvgl_v8/lvgl/src/misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lvgl_widgets
    ../func/lvgl_v8/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group lvgl_porting
    ../func/lvgl_v8/lvgl/porting/: lv_port_disp.c lv_port_indev.c lv_port_fs.c
  group func/TinyGPSPlus
    ../func/TinyGPSPlus/src/: TinyGPS++.cpp TinyGPS++.h
  group func/FatFs
    ../func/FatFs/ff13c/: ff.c ff.h ffconf.h diskio.c diskio.h
  group periph
    ../board/periph/led/: dev_led.c
    ../board/periph/key/: dev_key.c
    ../board/periph/lcd_led/: dev_lcd_led.c
    ../board/periph/ft5206/: dev_ft5206.c
  group driver
    ../board/: stm32f4xx_it.c board.c
    ../board/driver/: drv_usart.c drv_dbg.c drv_tim.c drv_sdram.c drv_ltdc.c drv_iic_soft.c drv_sdio_sd.c
  group STM32F4xx_StdPeriph_Driver
    ../board/fwlib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_tim.c stm32f4xx_fmc.c stm32f4xx_ltdc.c stm32f4xx_dma2d.c stm32f4xx_sdio.c
  group cmsis
    ../board/fwlib/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../board/fwlib/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
